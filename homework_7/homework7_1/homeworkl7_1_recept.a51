;RECEPT
ORG 0000H
	LJMP MAIN
ORG 0023H
	LJMP RINT
ORG 1000H
MAIN:
	SETB EA
	MOV TCON, #20H			;SET T1
	MOV TL1, #0FAH
	MOV TH1, #0FAH
	SETB TR1			;OPEN T1
	SETB ES
	MOV  PCON,#00H       ;SET UART
    MOV  SCON,#50H
	MOV P1,#00H
	SJMP $
RINT:
	MOV P1,#0FH	
	JB TI,INT_OVER		;RI INTERUPT
	CLR RI
	MOV A,SBUF
	MOV  P0,A			;LED
	INT_OVER:
	RETI
END
		